# Keil uVision project STC89C52RC.uvproj, settings and files
target STC89C52RC (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: STC89C52RC +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\System;..\Code_User
  group Code_User
    ../Code_User/: ProgramLogic.c Motor.c Delay.c Delay.h
  group System
    ../System/: main.c SYS_LOOP.c
