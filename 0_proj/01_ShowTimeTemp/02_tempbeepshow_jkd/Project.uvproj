# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware;.\Software
  group New Group
    ./: main.c
    ./Hardware/: AT24C02.c DS18B20.c ds1302_pz.c Key.c LCD1602.c Timer0.c
    ./Software/: Delay.c I2C.c OneWire.c
