# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\24c02;.\App\iic;.\App\key;.\App\smg;.\Public;.\App\ds18b20;.\App\ds1302;.\App\delay
  group User
    ./User/: main.c
  group App
    ./App/smg/: smg.c
    ./App/ds1302/: ds1302.c
    ./App/delay/: delay.c
    ./App/ds18b20/: ds18b20.c
  group Public
    ./Public/: public.c
