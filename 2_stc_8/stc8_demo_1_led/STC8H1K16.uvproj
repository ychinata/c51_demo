# Keil uVision project STC8H1K16.uvproj, settings and files
target Target (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: STC8H8K_demo +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group User
    ./User/: main.c
